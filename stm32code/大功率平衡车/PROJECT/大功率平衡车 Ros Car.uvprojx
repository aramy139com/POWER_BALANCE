# Keil uVision project 大功率平衡车 Ros Car.uvprojx, settings and files
target BALANCE (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Balance Ros Car +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\USER;..\FWLIB\inc;..\CORE;..\RosLibs;..\Bsp;..\SYSTEM\IIC;..\HARDWARE\battery;..\SYSTEM\Gpio;..\HARDWARE\Encoder;..\HARDWARE\IIC_device;..\HARDWARE\wheel;..\HARDWARE\Balance CAR
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group USER
    ../USER/: system_stm32f10x.c main.cpp
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/Gpio/: Gpio.cpp
    ../SYSTEM/IIC/: Wire.cpp WireBase.cpp
  group HARDWARE
    ../HARDWARE/battery/: battery.cpp
    ../HARDWARE/Encoder/: encoder.cpp
    ../HARDWARE/IIC_device/: mpu6050.cpp
    ../HARDWARE/wheel/: PID.cpp wheel.cpp
    ../HARDWARE/Balance CAR/: balance.cpp
  group ROSLIB
    ../RosLibs/: duration.cpp time.cpp
  group BSP
    ../Bsp/: millisecondtimer.c hardwareserial.cpp interrupt.cpp RingBuffer.cpp
